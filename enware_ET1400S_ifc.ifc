Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-02-26T14:52:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170117_1200(x64) - Exporter 16.0.1205.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 26 14:52:06 2021 * Host: PC-005 * Database: C:\Users\TESLAI~1\AppData\Local\Temp\{160C7C4A-D7A3-4102-A766-A9DEB6DC1140}\ifc * Database version: 5507 * Database creation date: Fri Feb 26 14:52:00 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 26 14:52:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 26 14:52:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: V:\Architecture Production\2021\MEP\13. Mark N\Tank shower with single piece frame\working\Febraury-2021\01.10-02-2021\ET1400S\26-02-2021\ET1400S.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 ft; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: ATM606, ET1400S:ATM606:56875
In: Level 1
Classification: D2010400 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: ATM606
Constraints - Level: Level: Level 1; Offset: 0 ft; Work Plane: Level : Level 1; Default Elevation: 3.93701 ft
Dimensions - Area: 150.139 ft2; Volume: 102.382 ft3
Identity Data - Mark: 1; Assembly Code: D2010400; Author: Yepsketch; Manufacturer: Enware; Model: EE120; OmniClass Number: 23.45.55.14; OmniClass Title: Single Faucets; Type Comments: SQX; Type Name: ATM606; URL: http://www.yepsketch.com
Other - Category: Plumbing Fixtures; Family: ET1400S: ATM606; Family and Type: ET1400S: ATM606; Schedule Level: Level: Level 1; Type: ET1400S: ATM606; Type Id: ET1400S: ATM606; Family Name: ET1400S
Phasing - Phase Created: New Construction
Mechanical - CWFU: 0.5; HWFU: 0.5
